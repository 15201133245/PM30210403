# IAR project ARM_SNPC.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AT91SAM7SE512 Atmel AT91SAM7SE512
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.PreInclude: Application\Project\Include\ProDef.h
  ICCARM.CCIncludePath2: Application\Project\Include\; Common\SAM7SE512\Include\; Common\Driver\include\; Application\CardReader\Include\; Application\Display\Include\; Application\Keypad\Include\; Application\POS\Include\; Application\PowerDown\Include\; Application\Print\Include\; Application\Pump\Include\; Application\Schedule\Include\; Application\Voice\Include\; Application\CashTrans\Include\; Application\PBOCTest\Include\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: Common\SAM7SE512\Include\
  OBJCOPY.OOCOutputFile: ARM_SNPC.bin
  ILINK.IlinkOutputFile: ARM_SNPC.out
  ILINK.IlinkIcfFile: D:\Gpay01\Gpay010511\Common\SAM7SE512\Resource\at91SAM7SE512_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: Application\Project\Include\; Common\SAM7SE512\Include\; Common\Driver\include\; Application\CardReader\Include\; Application\Display\Include\; Application\Keypad\Include\; Application\POS\Include\; Application\PowerDown\Include\; Application\Print\Include\; Application\Pump\Include\; Application\Schedule\Include\; Application\Voice\Include\
  OBJCOPY.OOCOutputFile: ARM_SNPC.srec
  group (top)
    Application/CardReader/Source/: SocialCard.c
    Application/CardReader/Include/: SocialCard.h
  group Application/CashTrans
    Application/CashTrans/Source/: CashTrans.c TestCashTrans.c
  group Application/Display
    Application/Display/Source/: Display.c DispPumpMsg.c Message.c Screen.c
  group Application/ICCard
    Application/CardReader/Source/: ACTCardProc.c CardReader.c CardReady.c CRCommand.c CRMemCopy.c CRMemFunc.c CRPowerOn.c CRPumpBusy.c CRPumpCall.c CRPumpEOT.c CRSFunc.c CRVaribles.c ExCRProc.c GreyCard.c ICCardCommand.c ICCardInProc.c ICCardInProc2.c ICCardProc.c Journal.c PSAMCommand.c PSAMProc.c RIDCardProc.c WorkMode.c WriteLog.c
  group Application/Keypad
    Application/Keypad/Source/: KeyMask.c Keypad.c Keypad2.c KeypadMain.c
  group Application/POS
    Application/POS/Source/: Arm70_POS_funtion.c POS.c Pos2DataFlash.c POSMode2.c PosMode2Func.c PosVar.c testPOS2.c TestPos2Mode.c
  group Application/PowerDown
    Application/Powerdown/Source/: PowerDown.c
  group Application/Printer
    Application/Print/Source/: CRPrint.c
  group Application/Project
    Application/Project/Source/: define.c main.c Pdprotect.c
  group Application/Pump
    Application/Pump/Source/: Pcomm.c Pinit.c Pump.c Pvar.c testPump.c Verify.c
  group Application/Schedule
    Application/Schedule/Source/: Schedule.c
  group Application/Voice
    Application/Voice/Source/: Voice.c
  group Common/Driver/Module
    Common/Driver/module/: at24.c at45.c at83.c DbugUsart.c m1172.c sem.c spi.c tc.c twi.c usart.c
  group Common/Driver/Source
    Common/Driver/src/: AscLog.c at83c26_app.c CardDrive.c control.c DbugUsartApp.c f_irq.c init.c key.c lcd.c list.c memoryCheck.c print.c record.c tools.c var.c
  group Common/SAM7SE
    Common/SAM7SE512/startup/: Cstartup.s Cstartup_SAM7.c
  group Include
    Common/Driver/include/: aic.h arm_bits.h at24.h at45.h at83.h board.h DbugUsart.h def.h func.h global.h InlineFunc.h iso7816.h m1172.h pdc.h pio.h pit.h pmc.h project.h sem.h smc.h spi.h tc.h trace.h twi.h usart.h WatchDog.h
    Common/SAM7SE512/Include/: AT91SAM7SE512.h AT91SAM7SE512_inc.h lib_AT91SAM7SE512.h
    Application/CardReader/Include/: cardreader.h CardReady.h CRCommand.h CRMemCopy.h CRPowerOn.h CRPumpBusy.h CRPumpCall.h CRPumpEOT.h CRSFunc.h CRVaribles.h ExCRProc.h GreyCard.h ICCardCommand.h ICCardInProc.h ICCardProc.h Journal.h PSAMCommand.h PSAMProc.h
    Application/CashTrans/Include/: CashTrans.h
    Application/Print/Include/: CRPrint.h
    Application/Project/Include/: define.h Pdprotect.h
    Application/Display/Include/: Display.h DispPumpMsg.h Message.h Screen.h
    Application/Keypad/Include/: KeyMask.h Keypad.h
    Application/PowerDown/Include/: PowerDown.h
    Application/Pump/Include/: Pump.h testPump.h
    Application/Schedule/Include/: Schedule.h
    Application/Voice/Include/: Voice.h
